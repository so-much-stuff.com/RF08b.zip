# EAGLE board RF08b (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DMA04  (via drill 0.61) (continued)
  Bottom 0.254: SV2.9 33.66,73.67 34.92,74.95 v39.37,74.95 v45.09,74.95 | v149.22,40.02 v123.83,40.02 | v149.22,47.01 IC31.8 | v45.09,88.92 71.75,88.92 72.39,88.28 80.01,88.28 80.64,88.92 v95.25,88.92 | v97.16,95.9 99.69,98.44 104.78,98.44 106.05,97.17 142.88,97.17 144.15,98.44 v146.05,98.44
DMA05  (via drill 0.61)
  Top 0.254: v36.83,57.16 v36.83,69.86 | v126.36,52.09 126.36,51.45 DMA4-7.6 | v48.26,69.86 v48.26,76.22 | v105.41,76.22 106.68,74.95 106.68,55.26 105.41,53.99 v105.41,53.36
  Bottom 0.254: v36.83,57.16 41.27,57.16 42.55,58.44 RS08.11 | SV2.11 33.66,71.14 34.92,69.86 v36.83,69.86 v48.26,69.86 | 127.64,53.36 v126.36,52.09 | 127.64,53.36 149.86,53.36 151.13,52.09 IC31.6 | v48.26,76.22 49.53,77.48 72.39,77.48 73.66,76.22 v105.41,76.22 | v105.41,53.36 106.68,52.09 119.38,52.09 120.65,53.36 127.64,53.36
DMA06  (via drill 0.61)
  Top 0.254: v40.01,55.9 39.37,56.53 39.37,60.34 38.73,60.98 v38.73,67.33 | v30.48,71.14 30.48,90.82 v33.02,93.36 | v59.05,93.36 v59.05,86.38 | v104.78,86.38 104.14,85.74 104.14,72.41 v104.78,71.77 | v120.65,71.14 121.92,69.86 121.92,61.61 122.56,60.98 123.83,60.98 123.83,59.07 DMA4-7.2
  Bottom 0.254: v38.73,67.33 34.92,67.33 33.66,68.59 SV2.13 33.02,69.23 31.11,71.14 v30.48,71.14 | v40.01,55.9 RS08.13 | DMA4-7.2 123.19,57.16 124.46,55.9 146.69,55.9 147.96,57.16 IC31.4 | v33.02,93.36 v59.05,93.36 | v59.05,86.38 81.92,86.38 82.55,85.74 97.16,85.74 97.79,86.38 v104.78,86.38 | v104.78,71.77 105.41,72.41 116.84,72.41 118.11,71.14 v120.65,71.14
DMA07  (via drill 0.61)
  Top 0.254: v34.29,54.62 34.29,64.15 33.02,65.42 SV2.15 33.02,66.69 34.29,67.96 34.29,71.77 34.92,72.41 37.47,72.41 37.47,80.03 38.73,81.3 38.73,83.2 v38.1,83.83 | v124.46,63.52 124.46,57.16 DMA4-7.3 | v87.63,83.2 v87.63,78.12 | v97.16,78.12 100.33,74.95 v100.33,68.59 | v104.78,67.96 v104.78,54.62
  Bottom 0.254: v34.29,54.62 36.2,54.62 37.47,53.36 RS08.15 | v124.46,63.52 140.34,63.52 142.88,60.98 149.86,60.98 151.13,62.24 IC31.2 | v38.1,83.83 38.73,84.47 67.31,84.47 69.22,82.56 78.11,82.56 78.74,83.2 v87.63,83.2 | v87.63,78.12 v97.16,78.12 | v100.33,68.59 100.97,67.96 v104.78,67.96 | v104.78,54.62 DMA4-7.3
DMA08  (via drill 0.61)
  Top 0.254: v40.01,60.98 40.01,58.44 41.27,57.16 41.27,53.36 43.18,51.45 RS08.17 | v125.09,74.31 123.19,76.22 DMA8-11.7 | v147.96,71.14 147.32,71.77 v147.32,77.48 | v31.75,74.95 31.75,65.42 33.02,64.15 SV2.17 | v27.3,74.95 v27.3,88.92 | v114.3,88.92 114.94,88.28 v114.94,79.39
  Bottom 0.254: v40.01,60.98 38.73,62.24 34.92,62.24 33.66,63.52 SV2.17 | v125.09,74.31 128.27,71.14 v147.96,71.14 | v147.32,77.48 148.59,78.75 IC24.8 | v31.75,74.95 v27.3,74.95 | v27.3,88.92 28.57,90.19 71.75,90.19 73.03,88.92 79.38,88.92 80.01,89.55 94.61,89.55 95.25,90.19 107.31,90.19 108.58,88.92 v114.3,88.92 | v114.94,79.39 118.11,76.22 DMA8-11.7
DMA09  (via drill 0.61)
  Top 0.254: v20.95,48.27 21.59,48.91 21.59,59.7 v20.95,60.34 | v30.48,66.06 30.48,64.15 33.02,61.61 SV2.19 | v13.34,69.86 v13.34,88.28 | v106.05,91.45 106.68,90.82 v106.68,81.3
  Bottom 0.254: v20.95,60.34 21.59,59.7 31.11,59.7 32.38,60.98 SV2.19 | v20.95,48.27 RS08.19 | IC24.6 151.13,83.83 149.86,82.56 125.73,82.56 DMA8-11.6 120.65,78.75 118.75,80.66 107.31,80.66 v106.68,81.3 | v30.48,66.06 26.67,69.86 v13.34,69.86 | v13.34,88.28 15.88,90.82 72.39,90.82 73.66,89.55 78.74,89.55 79.38,90.19 93.98,90.19 94.61,90.82 105.41,90.82 v106.05,91.45
DMA10  (via drill 0.61)
  Top 0.254: v20.32,57.16 19.68,56.53 v19.68,48.27 | v123.83,82.56 123.83,87.01 DMA8-11.2 | v73.66,90.82 v73.66,77.48 | v26.67,92.09 24.77,90.19 24.77,78.75 22.86,76.85 v22.86,63.52
  Bottom 0.254: DMA8-11.2 123.19,88.92 124.46,87.64 149.86,87.64 151.13,88.92 IC24.4 | v20.32,57.16 31.11,57.16 32.38,58.44 SV2.21 33.02,59.07 34.29,59.07 34.29,61.61 33.66,62.24 24.13,62.24 v22.86,63.52 | v19.68,48.27 20.95,47.01 32.38,47.01 33.02,47.64 37.47,47.64 39.37,45.73 RS08.21 | v123.83,82.56 106.68,82.56 100.97,76.85 74.3,76.85 v73.66,77.48 | v73.66,90.82 72.39,92.09 v26.67,92.09
DMA11  (via drill 0.61)
  Top 0.254: SV2.23 33.02,55.26 31.75,53.99 31.75,46.37 v34.92,43.2 34.29,42.56 34.29,34.94 34.92,34.3 36.2,34.3 36.83,33.67 36.83,27.32 36.2,26.69 34.29,26.69 v34.29,19.07 | v146.69,85.11 v146.69,92.72 | v66.04,19.07 67.31,20.34 v67.31,24.14 | v75.56,24.14 76.83,25.41 76.83,60.98 v76.2,61.61 | v95.25,60.98 v95.25,87.01
  Bottom 0.254: v34.92,43.2 RS08.23 | v146.69,85.11 124.46,85.11 123.19,86.38 DMA8-11.3 120.65,86.38 119.38,87.64 95.89,87.64 v95.25,87.01 | v146.69,92.72 147.96,94 IC24.2 | v34.29,19.07 40.64,19.07 43.18,16.53 55.88,16.53 58.42,19.07 v66.04,19.07 | v67.31,24.14 v75.56,24.14 | v76.2,61.61 76.83,60.98 v95.25,60.98
DMA-IN  (via drill 0.61)
  Top 0.254: v15.24,129.55 v12.7,127.02 | v83.19,134 84.45,135.27 84.45,147.33 85.09,147.97 117.47,147.97 117.47,144.79 118.11,144.16 118.11,143.52 v119.38,142.25 | v168.91,140.35 v173.99,135.27
  Bottom 0.254: v12.7,127.02 1.91,127.02 1.91,109.23 3.17,107.97 9.53,114.31 15.24,114.31 IC13.3 | v15.24,129.55 16.51,130.82 16.51,134 v83.19,134 | v119.38,142.25 140.34,142.25 141.6,140.98 150.5,140.98 151.13,141.62 167.64,141.62 v168.91,140.35 | v173.99,135.27 175.26,134 180.97,134 IC12.10
DMA-IN\  (via drill 0.61)
  Top 0.254: IC26.19 27.3,69.23 27.3,40.02 IC34.19 29.21,34.3 29.21,15.26 v30.48,13.99 | v197.49,147.97 190.5,147.97 189.23,146.7 189.23,142.25 180.34,133.36 IC12.11 | v210.19,47.64 207.65,45.1 v207.65,6.36 | v77.47,4.46 77.47,12.71 76.2,13.99 IC41.12
  Bottom 0.254: IC34.19 24.13,38.12 21.59,40.66 IC34.1 | v30.48,13.99 36.2,13.99 36.83,13.35 47.62,13.35 49.53,11.45 72.39,11.45 IC41.12 | v197.49,147.97 212.09,133.36 212.09,47.64 v210.19,47.64 | v207.65,6.36 205.1,3.83 187.32,3.83 186.69,4.46 184.15,4.46 182.88,3.19 128.91,3.19 127.64,4.46 v77.47,4.46
DMA-OUT\  (via drill 0.61)
  Top 0.254: v80.64,31.13 80.01,30.5 80.01,23.51 80.64,22.88 80.64,19.7 83.82,16.53 IC41.9 | IC28.19 62.87,69.23 62.87,40.02 IC35.19
  Bottom 0.254: IC28.1 54.61,73.67 57.15,71.14 IC28.19 | IC35.1 54.61,40.66 56.52,38.75 60.33,38.75 IC35.19 62.87,38.12 66.67,34.3 74.3,34.3 75.56,33.04 78.74,33.04 v80.64,31.13
DONE  (via drill 0.61)
  Top 0.254: 134.62,7.63 134.62,17.8 IC55.2 | 134.62,7.63 138.43,3.83 181.61,3.83 181.61,76.85 182.25,77.48 182.25,78.75 v181.61,79.39 | v37.47,34.3 37.47,35.58 35.56,37.48 SV1.23 | v41.27,33.04 40.64,32.4 40.64,20.34 40.01,19.7 v40.01,17.8 | v57.15,16.53 57.15,5.73 60.96,1.92 92.71,1.92 92.71,8.91 93.34,9.54 110.49,9.54 110.49,7.63 113.67,4.46 134.62,4.46 134.62,7.63
  Bottom 0.254: v181.61,79.39 197.49,95.27 200.66,95.27 204.47,99.08 IC11.9 | v37.47,34.3 38.73,33.04 v41.27,33.04 | v40.01,17.8 41.91,15.89 56.52,15.89 v57.15,16.53
DRV01\  (via drill 0.61)
  Top 0.254: v48.26,11.45 v48.26,25.41 | v73.66,11.45 IC41.4
  Bottom 0.254: v73.66,11.45 73.03,10.81 48.9,10.81 v48.26,11.45 | v48.26,25.41 RS08.38
DRV23\  (via drill 0.61)
  Top 0.254: v79.38,43.2 79.38,22.88 80.01,22.24 80.01,10.18 81.28,8.91 IC41.7
  Bottom 0.254: v79.38,43.2 78.74,43.83 74.93,43.83 74.3,44.47 56.52,44.47 55.24,45.73 RS08.22
DRVOK\  (via drill 0.61)
  Top 0.254: RS08.40 R2.1 45.72,17.16 44.45,15.89 44.45,8.91 v42.55,7 | v24.77,100.98 24.13,100.34 24.13,83.2 22.23,81.3 22.23,67.96 19.68,65.42 19.68,57.8 19.05,57.16 15.24,57.16 15.24,24.78 14.61,24.14 14.61,15.26 v21.59,8.27
  Bottom 0.254: IC21.13 47.62,103.52 46.35,103.52 IC21.14 42.55,100.98 v24.77,100.98 | v21.59,8.27 22.23,7.63 37.47,7.63 38.1,7 v42.55,7
EIE  (via drill 0.61)
  Top 0.254: IC37.2 196.22,26.05 196.22,10.81 189.23,3.83 187.96,3.83 INTENB.6 | v39.37,4.46 34.29,9.54 34.29,10.81 35.56,12.08 SV1.3 | v76.2,4.46 77.47,3.19 86.36,3.19 v86.36,19.07 | v125.73,20.97 v125.73,24.14 | v136.53,25.41 137.79,24.14 140.34,24.14 v140.34,17.8 | v142.88,16.53 142.88,12.08 IC55.9
  Bottom 0.254: IC55.9 146.05,10.18 147.32,8.91 168.91,8.91 170.18,7.63 185.42,7.63 INTENB.6 | v39.37,4.46 v76.2,4.46 | v86.36,19.07 87,19.7 109.22,19.7 109.86,20.34 119.38,20.34 120.65,21.61 125.09,21.61 v125.73,20.97 | v125.73,24.14 132.72,24.14 133.99,25.41 v136.53,25.41 | v140.34,17.8 141.6,16.53 v142.88,16.53
ERROR  (via drill 0.61)
  Top 0.254: v141.6,142.25 142.88,140.98 v142.88,128.28 141.6,127.02 141.6,8.91 146.05,8.91 146.69,9.54 146.69,10.81 IC55.10 | v177.16,127.65 177.8,127.02 IC12.3 177.8,122.57 176.53,121.3 176.53,114.31 175.26,113.05 IC7.2
  Bottom 0.254: v141.6,142.25 139.06,144.79 IC5.8 | v142.88,128.28 143.51,127.65 v177.16,127.65
ERROR\  (via drill 0.61)
  Top 0.254: v177.8,115.58 179.07,116.86 179.07,120.67 180.34,121.94 IC12.4 | IC18.5 v160.02,115.58
  Bottom 0.254: v160.02,115.58 v177.8,115.58
EXAD0\
  Bottom 0.254: IC26.18 24.13,68.59 22.86,67.33 6.99,67.33 6.35,66.69 6.35,64.15 7.62,64.15 C35L.34
EXAD1\
  Bottom 0.254: IC26.16 24.13,63.52 22.86,64.78 9.53,64.78 8.26,66.06 C35L.36
EXAD2\  (via drill 0.61)
  Top 0.254: v15.88,59.7 v15.88,72.41
  Bottom 0.254: v15.88,59.7 19.05,59.7 19.68,59.07 23.5,59.07 24.13,58.44 IC26.14 | v15.88,72.41 14.61,71.14 12.06,71.14 10.79,69.86 9.53,69.86 8.26,68.59 C35L.38
F.1  (via drill 0.61)
  Top 0.254: IC30.8 200.66,45.73 200.66,73.67 199.39,74.95 200.03,75.58 200.03,81.93 FIELD.3 | v136.53,147.97 137.79,149.24 v143.51,149.24 | v193.04,145.43 193.04,122.57 194.31,121.3 v194.31,90.82
  Bottom 0.254: 20.95,73.04 22.86,74.95 26.04,74.95 28.57,77.48 33.66,77.48 34.92,78.75 SV2.6 | 20.95,73.04 19.05,71.14 IC26.2 | 20.95,73.04 19.05,74.95 5.08,74.95 1.27,78.75 1.27,140.98 71.12,140.98 71.75,141.62 109.22,141.62 114.3,146.7 125.09,146.7 125.73,146.06 127.64,147.97 v136.53,147.97 | v143.51,149.24 189.23,149.24 v193.04,145.43 | v194.31,90.82 194.31,87.64 193.68,87.01 193.68,84.47 197.49,84.47 FIELD.3
F.2  (via drill 0.61)
  Top 0.254: IC26.4 20.95,69.23 v20.95,74.95 20.32,75.58 20.32,94 19.05,95.27 v19.05,98.44 | v210.82,81.3 212.09,80.03 212.09,42.56 v210.82,41.29 | v66.04,95.9 64.14,97.81 64.14,118.76 v64.77,119.39 | v186.69,128.28 v189.87,128.28
  Bottom 0.254: v20.95,74.95 26.04,80.03 33.66,80.03 34.92,81.3 SV2.4 | 207.01,85.11 200.66,85.11 199.39,86.38 FIELD.2 | 207.01,85.11 v210.82,81.3 | v210.82,41.29 207.65,38.12 IC30.11 | v19.05,98.44 19.68,99.08 60.96,99.08 62.23,97.81 64.14,97.81 65.41,99.08 66.67,99.08 67.31,98.44 67.31,95.9 v66.04,95.9 | v64.77,119.39 67.94,122.57 111.76,122.57 117.47,128.28 128.27,128.28 130.81,130.82 130.81,134 139.7,134 144.78,128.92 186.06,128.92 v186.69,128.28 | v189.87,128.28 197.49,120.67 198.75,120.67 203.84,115.58 205.1,115.58 207.65,113.05 207.65,85.11 207.01,85.11
F.3  (via drill 0.61)
  Top 0.254: v4.45,62.24 v4.45,78.12 3.81,78.75 3.81,103.52 4.45,104.16 4.45,109.23 3.81,109.87 3.81,144.16 v9.53,149.88 | v33.66,87.64 35.56,85.74 SV2.2 | v202.56,76.22 v202.56,118.12 | v128.27,146.7 125.09,149.88 84.45,149.88 83.19,148.6 82.55,149.24 54.61,149.24 53.34,147.97 50.16,147.97 48.9,149.24 v43.18,149.24
  Bottom 0.254: FIELD.6 v202.56,76.22 203.2,76.22 204.47,74.95 207.01,74.95 211.46,70.5 211.46,52.09 204.47,52.09 203.84,51.45 203.84,47.64 204.47,47.01 207.01,47.01 207.65,46.37 207.65,43.83 206.38,43.83 IC30.13 | v4.45,62.24 15.24,62.24 16.51,60.98 IC26.6 | v4.45,78.12 13.97,87.64 v33.66,87.64 | v202.56,118.12 207.65,123.2 208.91,123.2 209.55,123.84 209.55,134.63 206.38,134.63 198.75,142.25 142.88,142.25 139.7,145.43 136.53,145.43 135.25,146.7 v128.27,146.7 | v43.18,149.24 42.55,148.6 33.02,148.6 31.75,149.88 v9.53,149.88
GND  (via drill 0.61)
  Top 0.254: J14.2 J13.2 J12.2 J11.2 J10.2 J9.2 J8.2 | D34L.1 D34L.3 D34L.5 D34L.7 D34L.9 D34L.11 D34L.13 D34L.15 D34L.17 D34L.19 D34L.21 D34L.23 D34L.25 D34L.27 D34L.29 D34L.31 D34L.33 D34L.35 D34L.37 D34L.39 | 161.93,14.62 161.93,15.89 | 161.93,15.89 IC38.15 | IC38.13 161.93,14.62 | 161.93,15.89 161.93,20.97 IC38.17 | 161.93,14.62 161.93,9.54 IC38.11 | IC7.15 175.26,118.12 172.72,115.58 IC7.1 | C47.2 199.39,133.36 IC8.1 200.66,129.55 200.66,116.22 199.39,114.95 C12.2 199.39,113.68 200.03,113.05 200.03,91.45 C44.2 | IC6.8 165.1,135.9 168.91,132.09 168.91,127.65 170.18,126.38 C7.2 | v148.59,99.08 147.32,100.34 C18.2 147.32,113.68 145.41,115.58 145.41,125.75 C10.2 | 147.96,141.62 145.41,139.08 145.41,138.44 C6.2 | 147.96,141.62 149.86,143.52 IC6.15 | 147.96,141.62 151.13,138.44 151.13,134.63 152.4,133.36 IC10.12 | IC9.7 134.62,125.75 135.89,127.02 135.89,134.63 134.62,135.9 IC5.7 | IC7.8 190.5,113.05 189.23,114.31 189.23,121.94 187.96,123.2 IC12.7 | IC30.10 199.39,36.84 C37.2 | INTENB.8 INTENB.9 193.04,19.07 190.5,21.61 C36L.1 C36L.3 C36L.5 C36L.7 C36L.9 C36L.11 C36L.13 C36L.15 C36L.17 C36L.19 C36L.21 C36L.23 C36L.25 C36L.27 C36L.29 C36L.31 C36L.33 C36L.35 C36L.37 C36L.39 | C44.2 199.39,92.09 198.75,92.72 198.75,95.9 IC11.7 | FIELD.4 197.49,80.66 197.49,79.39 FIELD.5 196.22,76.85 | C30.2 199.39,64.15 198.75,64.78 198.75,70.5 FIELD.8 196.22,73.04 196.22,76.85 | 196.22,76.85 196.22,91.45 C44.2 | SV2.25 SV2.26 | C35.2 54.61,43.83 53.34,45.1 IC28.10 | C35L.1 C35L.3 C35L.5 C35L.7 C35L.9 C35L.11 C35L.13 C35L.15 C35L.17 C35L.19 C35L.21 C35L.23 C35L.25 C35L.27 C35L.29 C35L.31 C35L.33 C35L.35 C35L.37 C35L.39 10.16,71.77 10.79,72.41 10.79,94.63 11.43,95.27 11.43,110.5
  Top 0.254: C34.2 19.05,43.83 18.41,44.47 18.41,50.18 IC26.10 | IC16.15 96.52,118.12 93.98,115.58 IC16.1 93.98,110.5 92.71,109.23 92.71,99.71 91.44,98.44 C33.2 | v57.78,83.2 57.78,95.9 IC21.8 | v54.61,83.2 C28.2 | C21.2 38.1,98.44 39.37,99.71 39.37,109.23 40.64,110.5 IC14.1 41.27,111.14 42.55,111.14 IC14.2 IC14.13 | 11.43,110.5 6.35,105.42 6.35,99.71 5.08,98.44 C20.2 | IC13.1 11.43,110.5 | IC9.12 124.46,130.82 122.56,128.92 122.56,125.11 IC9.2 | IC4.7 107.31,136.54 108.58,136.54 IC4.8 | IC2.7 51.44,136.54 52.7,136.54 IC2.8 | C5.2 116.84,137.81 115.57,136.54 115.57,127.65 116.84,126.38 C9.2 116.84,125.11 117.47,124.47 117.47,118.12 119.38,116.22 C17.2 119.38,112.41 120.02,111.78 120.02,92.72 | D35L.39 D35L.37 D35L.35 D35L.33 D35L.31 D35L.29 D35L.27 D35L.25 D35L.23 D35L.21 D35L.19 D35L.17 D35L.15 D35L.13 D35L.11 D35L.9 D35L.7 D35L.5 D35L.3 D35L.1 73.03,22.88 67.31,17.16 67.31,13.35 63.5,9.54 C41.2 | v43.18,19.07 RS08.39 43.18,23.51 41.91,24.78 41.91,31.13 43.18,32.4 RS08.31 | 62.87,26.05 62.87,24.78 IC35.13 | 62.87,26.05 IC35.15 | 62.87,26.05 62.87,31.13 IC35.17 | v53.98,8.91 53.98,17.16 IC35.10 | C27.2 139.06,94 139.06,85.74 DAR8-11.4 139.06,81.93 139.06,75.58 DAR8-11.8 138.43,72.41 C42.2 | IC24.10 153.67,72.41 C31.2 | C39.2 123.19,62.88 122.56,63.52 122.56,73.04 DMA8-11.8 120.02,75.58 120.02,81.93 | 120.02,81.93 DMA8-11.4 | 120.02,92.72 121.28,92.72 122.56,94 C8.2 | 120.02,92.72 120.02,81.93 | v115.57,17.8 114.3,19.07 D36L.1 D36L.3 D36L.5 D36L.7 D36L.9 D36L.11 D36L.13 D36L.15 D36L.17 D36L.19 D36L.21 D36L.23 D36L.25 D36L.27 D36L.29 D36L.31 D36L.33 D36L.35 D36L.37 D36L.39
  Top 0.254: IC31.10 153.67,40.66 C38.2 | C40.2 138.43,40.66 DAR4-7.8 135.25,43.83 135.25,50.18 DAR4-7.4
  Bottom 0.254: D34L.17 J6.2 | D34L.13 J8.2 | IC23.7 DMA0-3.8 123.19,7.63 124.46,8.91 134.62,8.91 135.89,7.63 IC55.7 138.43,7.63 139.7,6.36 149.86,6.36 151.13,7.63 IC38.10 IC38.11 | 172.72,12.08 161.93,12.08 161.29,12.71 IC38.13 | 172.72,12.08 180.97,12.08 INTENB.4 183.51,9.54 184.78,9.54 INTENB.5 187.32,12.08 191.13,12.08 INTENB.8 195.58,7.63 IC37.10 | 172.72,12.08 C43.2 | D34L.1 172.09,22.88 170.81,24.14 163.83,24.14 162.56,22.88 IC38.17 | IC18.7 166.37,113.05 C11.2 171.45,113.05 IC7.1 174.62,113.68 192.41,113.68 | 192.41,113.68 193.04,114.31 C12.2 | IC7.8 192.41,113.68 | IC6.8 167,139.08 171.45,139.08 C45.- | IC12.7 186.06,126.38 170.18,126.38 C7.2 163.83,125.75 IC10.7 160.66,126.38 147.96,126.38 | v148.59,99.08 C24.2 | C18.2 140.97,113.05 IC17.8 137.79,109.87 123.83,109.87 IC17.1 120.65,113.05 C17.2 113.03,113.05 IC16.8 109.86,109.87 95.89,109.87 IC16.1 92.71,113.05 C16.2 91.44,113.68 83.82,113.68 | IC9.7 135.89,125.75 C10.2 144.78,126.38 147.96,126.38 | 147.96,126.38 IC10.2 | IC5.7 135.89,138.44 C6.2 | INTENB.9 IC37.6 | C36L.13 IC30.10 | IC11.7 195.58,96.53 IC19.7 187.96,90.19 186.69,90.19 186.69,97.81 186.06,98.44 179.07,98.44 178.44,99.08 C19.2 | FIELD.9 FIELD.8 C36L.39 | C36L.21 IC30.6 | SV2.26 36.2,53.36 37.47,52.09 50.8,52.09 52.07,50.81 IC28.10 | C35L.27 IC26.8 19.05,55.9 20.32,54.62 26.67,54.62 27.94,53.36 SV2.25 | IC34.10 16.51,17.8 15.88,18.43 7.62,18.43 4.45,21.61 4.45,39.38 8.26,39.38 9.53,40.66 C35L.15 | J2.2 5.71,50.81 6.99,49.55 8.26,49.55 9.53,50.81 C35L.23 IC26.10 | IC22.7 85.09,97.81 C33.2 | 83.82,113.68 78.11,113.68 IC15.4 74.3,113.68 67.94,113.68 67.31,113.05 C15.2 57.15,113.05 IC14.7 53.98,109.87 46.35,109.87
  Bottom 0.254: 83.82,113.68 IC15.7 | C26.2 18.41,76.22 17.78,76.85 4.45,76.85 3.17,78.12 3.17,97.81 C20.2 | v57.78,83.2 v54.61,83.2 | C22.2 65.41,97.81 64.77,97.17 59.05,97.17 IC21.8 56.52,98.44 38.1,98.44 C21.2 | C13.2 10.79,113.05 11.43,112.41 12.06,112.41 IC13.1 13.34,111.14 14.61,111.14 IC13.2 17.14,109.87 18.41,109.87 IC13.4 22.23,109.87 26.04,109.87 IC13.7 29.21,113.05 C14.2 38.73,113.05 39.37,112.41 40.01,112.41 IC14.1 | 46.35,109.87 45.09,109.87 IC14.2 | 46.35,109.87 IC14.4 | C9.2 117.47,125.75 118.11,126.38 120.02,126.38 IC9.2 | C5.2 116.2,138.44 115.57,137.81 109.86,137.81 IC4.8 | IC2.8 53.98,137.81 59.69,137.81 60.33,138.44 C3.2 60.96,139.08 76.83,139.08 IC3.7 79.38,136.54 80.64,136.54 IC3.8 81.92,137.81 87.63,137.81 88.27,138.44 C4.2 88.9,139.08 104.78,139.08 IC4.7 | C1.2 5.71,138.44 6.35,139.08 20.95,139.08 IC1.7 23.5,136.54 24.77,136.54 IC1.8 26.04,137.81 31.75,137.81 32.38,138.44 C2.2 33.02,139.08 48.9,139.08 IC2.7 | D35L.19 79.38,45.73 80.64,44.47 C32.2 81.28,45.1 92.08,45.1 | 92.08,45.1 IC32.5 | 92.08,45.1 99.69,45.1 IC32.8 | 92.08,75.58 81.28,75.58 C25.2 80.64,74.95 76.83,71.14 D35L.39 | 92.08,75.58 IC25.5 | 92.08,75.58 99.69,75.58 IC25.8 | D35L.31 73.66,60.34 80.01,60.34 80.64,59.7 C29.2 81.28,60.34 92.08,60.34 IC29.5 95.89,56.53 99.69,56.53 IC29.8 | v43.18,19.07 50.8,19.07 52.07,17.8 IC35.10 | IC23.2 94.61,9.54 91.44,9.54 C23.2 85.09,8.91 IC41.8 81.92,9.54 63.5,9.54 C41.2 v53.98,8.91 | D35L.1 79.38,22.88 80.64,24.14 C36.2 81.28,20.97 95.89,20.97 | IC35.17 62.23,33.04 62.87,32.4 69.85,32.4 70.48,31.77 71.75,31.77 73.03,30.5 D35L.7 | IC24.10 151.13,73.67 150.5,73.04 146.69,73.04 146.05,72.41 140.97,72.41 139.7,73.67 DAR8-11.8
  Bottom 0.254: C27.2 137.79,94 136.53,95.27 125.09,95.27 123.83,94 C8.2 | IC36.4 92.08,22.24 93.34,22.24 IC36.5 95.89,20.97 | 95.89,20.97 99.69,20.97 IC36.8 102.87,21.61 112.39,21.61 113.67,22.88 D36L.1 | v115.57,17.8 DMA0-3.4 | IC31.10 151.13,41.92 150.5,41.29 146.69,41.29 146.05,40.66 139.7,40.66 138.43,41.92 DAR4-7.8 | D36L.5 C46.2 | DMA4-7.8 120.65,41.92 119.38,40.66 D36L.15 | 119.38,50.81 120.65,52.09 DMA4-7.4 | D36L.23 119.38,50.81 | 119.38,50.81 134.62,50.81 135.89,52.09 DAR4-7.4 | C39.2 116.2,62.24 114.94,63.52 D36L.33
INT_RQ\  (via drill 0.61)
  Top 0.254: IC55.3 135.25,15.89 135.25,12.08 IC55.6 | v147.96,55.9 147.32,55.26 147.32,29.86 144.78,27.32 144.78,25.41 147.32,22.88 147.32,8.91 146.05,7.63 IC55.8
  Bottom 0.254: IC55.6 138.43,10.18 140.97,7.63 IC55.8 | v147.96,55.9 161.29,55.9 163.19,57.8 168.91,57.8 169.54,58.44 D34L.30
IOS\  (via drill 0.61)
  Top 0.254: v76.2,83.83 77.47,85.11 77.47,97.81 78.74,99.08 IC22.10 | v72.39,26.69 v72.39,83.83 | v99.06,25.41 100.33,24.14 100.33,12.71 102.87,10.18 111.12,10.18 111.12,9.54 115.57,5.09 116.84,5.09 v116.84,26.69 | v171.45,29.23 171.45,51.45 170.81,52.09 169.54,52.09 168.91,52.72 168.91,53.99 170.18,55.26 D34L.28
  Bottom 0.254: v72.39,83.83 v76.2,83.83 | v72.39,26.69 93.34,26.69 94.61,25.41 v99.06,25.41 | v116.84,26.69 131.44,26.69 132.08,26.05 135.89,26.05 136.53,26.69 145.41,26.69 146.05,26.05 150.5,26.05 151.13,26.69 161.93,26.69 164.47,29.23 v171.45,29.23
MYDEV\  (via drill 0.61)
  Top 0.254: IC25.4 91.44,68.59 90.17,67.33 90.17,64.78 90.81,64.15 90.81,60.34 91.44,59.7 IC29.4 91.44,53.99 v90.17,52.72 | v97.16,40.66 101.6,36.21 PAD1.1 | v91.44,47.01 IC32.4
  Bottom 0.254: v97.16,40.66 93.98,40.66 IC32.4 | v90.17,52.72 85.72,52.72 85.09,52.09 85.09,46.37 90.81,46.37 v91.44,47.01
N$1
  Top 0.254: IC36.9 PAD8.1
N$2  (via drill 0.61)
  Top 0.254: v165.1,130.82 166.37,129.55 v166.37,105.42
  Bottom 0.254: v165.1,130.82 163.83,130.82 IC10.8 | v166.37,105.42 203.2,105.42 204.47,104.16 IC11.11
N$3  (via drill 0.61)
  Top 0.254: v126.36,46.37 126.36,41.29 120.02,34.94 120.02,17.16 DMA0-3.5
  Bottom 0.254: v126.36,46.37 DMA4-7.12
N$4  (via drill 0.61)
  Top 0.254: SW1.1 8.26,123.84 9.53,123.84 SW1.2 10.79,123.84 12.06,123.84 SW1.3 | SW1.4 15.88,123.84 17.14,123.84 SW1.5 18.41,123.84 19.68,123.84 SW1.6 20.95,123.84 22.23,123.84 SW1.7 | v28.57,88.92 27.94,89.55 27.94,94 26.67,95.27 26.67,107.97 24.13,110.5 24.13,113.05 26.67,115.58 26.67,121.94 25.4,123.2 SW1.8 | v48.26,87.64 IC21.4
  Bottom 0.254: SW1.4 14.61,123.84 13.34,123.84 SW1.3 | SW1.8 24.77,123.84 23.5,123.84 SW1.7 | v48.26,87.64 34.92,87.64 33.66,88.92 v28.57,88.92
N$5
  Top 0.254: IC36.15 PAD2.1
N$6
  Top 0.254: IC36.14 PAD3.1
N$7
  Top 0.254: IC36.13 PAD4.1
N$8
  Top 0.254: IC36.12 PAD5.1
N$9
  Top 0.254: IC36.11 PAD6.1
N$10
  Top 0.254: IC36.10 PAD7.1
N$11  (via drill 0.61)
  Top 0.254: v104.14,29.23 PAD9.1
  Bottom 0.254: v104.14,29.23 99.06,24.14 IC36.7
N$12  (via drill 0.61)
  Top 0.254: 142.24,83.83 142.24,57.16 DAR4-7.14 | 142.24,83.83 DAR8-11.14 | v143.51,114.31 142.24,113.05 142.24,83.83 | v165.1,114.31 IC18.8
  Bottom 0.254: v165.1,114.31 164.47,114.95 160.66,114.95 160.02,114.31 v143.51,114.31
N$13  (via drill 0.61)
  Top 0.254: v120.65,63.52 120.02,62.88 120.02,51.45 DMA4-7.5 | v128.27,65.42 127.64,66.06 127.64,79.39 DMA8-11.12
  Bottom 0.254: v120.65,63.52 122.56,65.42 v128.27,65.42
N$14  (via drill 0.61)
  Top 0.254: v53.34,127.65 54.61,128.92 55.88,128.92 IC14.8 55.88,116.22 57.15,114.95 57.15,112.41 v57.78,111.78 | IC13.8 v27.94,123.84
  Bottom 0.254: v27.94,123.84 31.75,127.65 v53.34,127.65 | v57.78,111.78 59.69,109.87 79.38,109.87 IC15.6
N$15  (via drill 0.61)
  Top 0.254: v41.91,149.88 41.91,142.25 45.72,138.44 IC2.5 | v118.11,148.6 120.65,146.06 120.65,139.71 121.92,138.44 IC5.2
  Bottom 0.254: v41.91,149.88 42.55,150.51 81.28,150.51 83.19,148.6 v118.11,148.6
N$16  (via drill 0.61)
  Top 0.254: v134.62,36.21 133.99,35.58 133.99,13.99 132.08,13.99 130.81,15.26 DMA0-3.12 | v130.81,38.75 131.44,39.38 131.44,61.61 130.81,62.24 130.81,66.69 132.72,68.59 v132.72,80.03
  Bottom 0.254: v134.62,36.21 132.08,38.75 v130.81,38.75 | v132.72,80.03 133.99,81.3 DAR8-11.5
N$17
  Top 0.254: SW2.1 36.2,123.84 37.47,123.84 SW2.2 38.73,123.84 40.01,123.84 SW2.3 41.27,123.84 42.55,123.84 SW2.4 43.81,123.84 45.09,123.84 SW2.5 | IC21.5 50.8,97.81 49.53,99.08 49.53,121.3 48.26,122.57 SW2.6 | SW2.8 52.7,123.84 51.44,123.84 SW2.7
  Bottom 0.254: SW2.7 50.16,123.84 48.9,123.84 SW2.6 47.62,123.84 46.35,123.84 SW2.5
N$18
  Top 0.254: IC18.6 162.56,113.05 161.29,114.31 161.29,125.75 IC10.11
N$19  (via drill 0.61)
  Top 0.254: v52.07,117.49 52.07,99.08 53.34,97.81 IC21.6 | SW3.1 64.14,123.84 65.41,123.84 SW3.2 66.67,123.84 67.94,123.84 SW3.3 69.22,123.84 70.48,123.84 SW3.4 71.75,123.84 73.03,123.84 SW3.5 74.3,123.84 75.56,123.84 SW3.6 76.83,123.84 78.11,123.84 SW3.7 79.38,123.84 80.64,123.84 SW3.8
  Bottom 0.254: v52.07,117.49 57.78,117.49 63.5,123.2 SW3.1
N$20  (via drill 0.61)
  Top 0.254: SW4.1 92.08,123.84 93.34,123.84 SW4.2 94.61,123.84 95.89,123.84 SW4.3 | v94.61,100.98 95.25,101.61 95.25,115.58 97.79,118.12 97.79,121.94 96.52,123.2 SW4.3 | IC21.7 v55.88,100.98 | SW4.3 97.16,123.84 98.42,123.84 SW4.4 99.69,123.84 100.97,123.84 SW4.5 | SW4.6 104.78,123.84 106.05,123.84 SW4.7 107.31,123.84 108.58,123.84 SW4.8
  Bottom 0.254: v55.88,100.98 v94.61,100.98 | SW4.6 103.5,123.84 102.23,123.84 SW4.5
N$21  (via drill 0.61)
  Top 0.254: v73.03,140.35 73.03,139.08 73.66,138.44 IC3.5 | v79.38,140.35 82.55,143.52 v82.55,147.97 | v125.73,147.33 125.73,140.35 127,139.08 IC5.4
  Bottom 0.254: v79.38,140.35 v73.03,140.35 | v82.55,147.97 83.19,147.33 v125.73,147.33
N$22  (via drill 0.61)
  Top 0.254: DMA0-3.14 127.64,22.24 127.64,26.05 128.27,26.69 129.54,26.69 129.54,39.38 127.64,41.29 127.64,52.72 DMA4-7.14 127,57.16 127,83.83 DMA8-11.14 | v153.67,105.42 153.67,113.05 156.84,116.22 156.84,117.49 157.48,118.12 IC18.11 | v132.72,104.79 v132.72,86.38
  Bottom 0.254: v153.67,105.42 153.03,104.79 v132.72,104.79 | v132.72,86.38 DMA8-11.14
N$23
  Bottom 0.254: IC1.5 19.68,135.27 117.47,135.27 IC5.1
N$24  (via drill 0.61)
  Top 0.254: v113.67,144.79 113.67,146.7 100.97,146.7 100.33,146.06 100.33,143.52 100.97,142.89 100.97,139.08 101.6,138.44 IC4.5 | v127.64,140.35 129.54,138.44 IC5.5
  Bottom 0.254: v113.67,144.79 118.11,140.35 v127.64,140.35
N$25  (via drill 0.61)
  Top 0.254: v133.99,49.55 v133.99,64.78 | v143.51,64.78 142.88,65.42 142.88,79.39 DAR8-11.12
  Bottom 0.254: v133.99,64.78 v143.51,64.78 | v133.99,49.55 DAR4-7.5
N$26  (via drill 0.61)
  Top 0.254: v105.41,99.08 105.41,116.86 106.68,118.12 IC16.11
  Bottom 0.254: v105.41,99.08 90.81,99.08 90.17,98.44 70.48,98.44 IC22.1
N$27  (via drill 0.61)
  Top 0.254: v128.91,106.7 129.54,107.33 IC17.4
  Bottom 0.254: v128.91,106.7 116.84,106.7 116.2,107.33 111.76,107.33 111.12,106.7 78.74,106.7 IC22.11
N$28  (via drill 0.61)
  Top 0.254: v173.99,107.97 173.99,91.45 172.72,90.19 IC19.1
  Bottom 0.254: v173.99,107.97 175.9,109.87 180.97,109.87 IC7.5
N$29
  Top 0.254: RA.2 RB.1 208.28,122.57 209.55,123.84 209.55,125.75 IC8.7
N$30
  Top 0.254: IC8.3 196.85,127.02 195.58,128.28 RL.2
  Bottom 0.254: IC12.9 187.96,129.55 RL.2
N$32
  Top 0.254: RB.2 198.75,121.94 200.03,123.2 200.03,127.65 IC8.2 | C47.1 204.47,134 203.84,133.36 203.84,128.92 IC8.6
  Bottom 0.254: IC8.6 204.47,127.02 201.93,129.55 IC8.2
N$33
  Top 0.254: IC19.11 180.34,97.81 181.61,99.08 181.61,115.58 182.88,116.86 IC7.12
N$34
  Top 0.254: IC8.5 C48.2
N$53
  Bottom 0.254: SW1.16 9.53,130.19 13.34,130.19 13.97,130.82 13.97,136.54 14.61,136.54 IC1.4
N$54
  Top 0.254: SW1.15 10.16,133.36 12.7,135.9 IC1.3
N$55
  Bottom 0.254: SW1.14 12.7,133.36 10.16,135.9 IC1.2
N$56
  Top 0.254: IC1.1 7.62,135.9 8.89,134.63 8.89,130.82 9.53,130.19 14.61,130.19 14.61,131.46 SW1.13
N$57  (via drill 0.61)
  Top 0.254: v15.24,142.25 16.51,140.98 16.51,135.9 SW1.11
  Bottom 0.254: v15.24,142.25 IC1.14
N$58
  Top 0.254: SW1.10 19.05,135.9 19.05,139.71 15.24,143.52 IC1.13
N$59
  Top 0.254: SW1.9 25.4,133.36 24.13,134.63 24.13,138.44 IC1.12
N$60
  Top 0.254: SW1.12 13.97,135.9 13.97,146.06 13.34,146.7 10.16,146.7 IC1.15
N$61
  Top 0.254: SW2.16 35.56,133.36 36.83,134.63 36.83,138.44 37.47,139.08 42.55,139.08 42.55,137.81 IC2.4
N$62
  Top 0.254: SW2.15 38.1,133.36 40.64,135.9 IC2.3
N$63
  Top 0.254: SW2.14 38.73,130.19 36.83,130.19 36.83,133.36 38.1,134.63 IC2.2
N$64
  Top 0.254: IC2.1 35.56,135.9 34.29,134.63 34.29,130.82 35.56,129.55 42.55,129.55 42.55,131.46 SW2.13
N$65
  Top 0.254: SW2.11 44.45,135.9 44.45,138.44 40.64,142.25 IC2.14
N$66
  Top 0.254: SW2.10 46.99,135.9 46.99,139.71 43.18,143.52 IC2.13
N$67
  Top 0.254: SW2.9 49.53,135.9 49.53,139.71 45.72,143.52 IC2.12
N$68
  Top 0.254: SW3.16 63.5,133.36 64.77,134.63 64.77,138.44 65.41,139.08 71.12,139.08 IC3.4
N$69
  Top 0.254: SW3.15 66.04,133.36 68.58,135.9 IC3.3
N$70
  Top 0.254: SW3.14 66.67,130.19 64.77,130.19 64.77,133.36 66.04,134.63 IC3.2
N$71
  Top 0.254: IC3.1 63.5,135.9 62.23,134.63 62.23,130.82 63.5,129.55 70.48,129.55 70.48,131.46 SW3.13
N$72
  Top 0.254: SW3.11 72.39,135.9 72.39,139.71 68.58,143.52 IC3.14
N$73
  Top 0.254: SW3.10 74.93,135.9 74.93,139.71 71.12,143.52 IC3.13
N$74
  Top 0.254: SW3.9 77.47,135.9 77.47,139.71 73.66,143.52 IC3.12
N$75
  Top 0.254: SW4.16 93.34,130.19 97.79,130.19 97.79,133.36 99.06,134.63 IC4.4
N$76
  Top 0.254: SW4.15 93.98,133.36 96.52,135.9 IC4.3
N$77
  Top 0.254: SW4.14 96.52,133.36 97.79,134.63 97.79,138.44 97.16,139.08 93.98,139.08 IC4.2
N$78
  Top 0.254: IC4.1 91.44,135.9 90.17,134.63 90.17,130.82 91.44,129.55 98.42,129.55 98.42,131.46 SW4.13
N$79  (via drill 0.61)
  Top 0.254: v92.71,134 92.71,139.71 96.52,143.52 IC4.14
  Bottom 0.254: v92.71,134 102.23,134 SW4.11
N$80
  Top 0.254: SW4.10 103.5,135.27 100.33,135.27 100.33,142.25 99.06,143.52 IC4.13
N$81
  Top 0.254: SW4.9 105.41,135.9 105.41,139.71 101.6,143.52 IC4.12
N$82
  Top 0.254: SW4.12 101.6,130.82 98.42,127.65 89.53,127.65 89.53,137.17 90.17,137.81 90.17,139.71 93.98,143.52 IC4.15
N$83
  Top 0.254: SW3.12 73.66,130.82 70.48,127.65 61.59,127.65 61.59,137.17 62.23,137.81 62.23,139.08 66.04,142.89 IC3.15
N$84
  Top 0.254: SW2.12 45.72,130.82 42.55,127.65 34.29,127.65 34.29,129.55 33.66,130.19 33.66,137.17 34.29,137.81 34.29,139.71 38.1,143.52 IC2.15
NXD  (via drill 0.61)
  Top 0.254: v35.56,5.73 31.75,9.54 31.75,28.59 32.38,29.23 34.92,29.23 34.92,30.5 SV1.17 | v99.69,3.19 IC23.5 | v186.69,3.19 v186.69,52.09
  Bottom 0.254: v35.56,5.73 36.83,5.73 39.37,3.19 77.47,3.19 78.11,3.83 99.06,3.83 v99.69,3.19 100.97,1.92 185.42,1.92 v186.69,3.19 | v186.69,52.09 195.58,52.09 196.85,53.36 IC30.4
NXD\  (via drill 0.61)
  Top 0.254: v182.88,4.46 182.88,1.92 107.95,1.92 106.68,3.19 IC23.6 | v189.23,5.09 189.23,113.05 186.69,115.58 186.69,127.02 184.15,129.55 v184.15,135.9 | v184.15,140.98 179.71,145.43 179.71,149.88 144.78,149.88 144.78,149.24 v139.06,143.52
  Bottom 0.254: v182.88,4.46 183.51,5.09 v189.23,5.09 | v184.15,140.98 v184.15,135.9 | v139.06,143.52 138.43,142.89 126.36,142.89 IC5.12
PBIT  (via drill 0.61)
  Top 0.254: v54.61,127.65 54.61,114.31 53.34,113.05 IC14.6 | v80.64,127.65 88.27,120.03 v88.27,105.42 | v96.52,104.16 95.89,103.52 95.89,90.82 93.98,88.92 v93.98,87.64 | v82.55,87.01 82.55,72.41 80.01,69.86 80.01,57.16 v81.28,55.9 | v92.71,55.9 92.71,17.8 90.17,15.26 90.17,6.36 90.81,5.73 87.63,2.56 61.59,2.56 61.59,4.46 60.33,5.73 60.33,17.16 IC35.11
  Bottom 0.254: v80.64,127.65 v54.61,127.65 | v88.27,105.42 89.53,104.16 v96.52,104.16 | v93.98,87.64 93.34,87.01 v82.55,87.01 | v92.71,55.9 v81.28,55.9
PCA  (via drill 0.61)
  Top 0.254: v200.66,130.82 203.84,127.65 203.84,116.86 207.65,113.05 207.65,50.18 207.01,49.55 201.93,49.55 201.93,16.53 IC37.8
  Bottom 0.254: IC55.5 138.43,12.71 139.7,13.99 166.37,13.99 167.64,12.71 IC37.8 | v200.66,130.82 189.23,130.82 IC12.8
PER  (via drill 0.61)
  Top 0.254: v208.91,59.07 208.91,81.93 210.19,83.2 210.19,130.82 200.03,140.98 200.03,150.51 135.25,150.51 130.81,146.06 130.81,134.63 132.08,133.36 IC9.9 | v41.91,36.84 44.45,36.84 44.45,34.94 45.09,34.3 46.99,34.3 46.99,11.45 v51.44,7 | v61.59,5.73 62.87,4.46 74.93,4.46 v74.93,11.45 | v101.6,12.71 102.87,13.99 102.87,46.37 106.68,50.18 106.68,53.99 107.31,54.62 107.31,79.39 105.41,81.3 105.41,85.74 106.05,86.38 106.05,90.19 104.78,91.45 v104.78,92.09 | v121.28,94.63 122.56,95.9 122.56,109.87 123.19,110.5 123.19,115.58 125.73,118.12 125.73,120.67 128.27,123.2 v128.27,127.02
  Bottom 0.254: v208.91,59.07 207.01,57.16 204.47,57.16 203.2,58.44 IC30.2 | v41.91,36.84 37.47,36.84 36.2,35.58 SV1.21 | v51.44,7 60.33,7 v61.59,5.73 | v74.93,11.45 76.2,12.71 v101.6,12.71 | v104.78,92.09 106.05,93.36 115.57,93.36 116.84,94.63 v121.28,94.63 | v128.27,127.02 132.08,130.82 IC9.9
PER\
  Top 0.254: IC9.8 134.62,133.36 133.35,134.63 133.35,142.25 132.08,143.52 IC5.9
  Bottom 0.254: IC5.10 130.18,144.16 131.44,144.16 IC5.9
PIE  (via drill 0.61)
  Top 0.254: v140.34,15.26 140.34,4.46 172.09,4.46 INTENB.2 177.8,11.45 179.07,12.71 179.07,20.97 v179.71,21.61 | v194.94,49.55 192.41,47.01 v192.41,22.88 | v36.83,8.91 36.83,13.35 35.56,14.62 SV1.5 | v62.23,15.26 v62.23,7.63
  Bottom 0.254: v140.34,15.26 IC55.4 135.89,15.26 134.62,16.53 115.57,16.53 114.94,17.16 85.72,17.16 85.09,17.8 64.77,17.8 v62.23,15.26 | v194.94,49.55 200.66,49.55 204.47,53.36 IC30.17 | v192.41,22.88 191.13,21.61 v179.71,21.61 | v36.83,8.91 37.47,9.54 52.07,9.54 53.98,7.63 v62.23,7.63
PROTECT  (via drill 0.61)
  Top 0.254: v151.13,140.35 152.4,139.08 IC6.3 | IC5.6 v132.08,140.98
  Bottom 0.254: v132.08,140.98 132.72,140.35 v151.13,140.35
SETNXD\  (via drill 0.61)
  Top 0.254: v102.87,117.49 102.87,126.38 89.53,126.38 80.01,135.9 80.01,138.44 77.47,140.98 77.47,146.7 65.41,146.7 64.77,146.06 64.77,142.89 63.5,142.89 59.69,139.08 59.69,123.2 59.05,122.57 59.05,106.06 58.42,105.42 IC21.9 | v116.2,118.12 117.47,116.86 117.47,111.14 119.38,109.23 v119.38,9.54
  Bottom 0.254: v102.87,117.49 102.87,121.3 113.03,121.3 v116.2,118.12 | v119.38,9.54 103.5,9.54 IC23.4
SETPER\  (via drill 0.61)
  Top 0.254: v24.13,126.38 24.13,114.31 22.86,113.05 IC13.5
  Bottom 0.254: v24.13,126.38 26.67,128.92 126.36,128.92 IC9.10
SETWLS\  (via drill 0.61)
  Top 0.254: v139.06,130.19 140.34,131.46 140.34,142.25 144.78,146.7 158.75,146.7 158.75,130.82 159.38,130.19 161.29,130.19 161.29,133.36 162.56,134.63 IC6.7
  Bottom 0.254: v139.06,130.19 132.72,130.19 IC9.4
SKIP\  (via drill 0.61)
  Top 0.254: IC19.6 185.42,90.19 182.88,92.72 IC19.10 v182.88,103.52 | v124.46,104.16 IC17.2
  Bottom 0.254: R1.1 170.81,86.38 171.45,87.01 173.35,87.01 IC19.2 177.16,87.01 183.51,87.01 IC19.6 | v124.46,104.16 125.09,103.52 132.72,103.52 133.35,104.16 170.18,104.16 170.81,104.79 181.61,104.79 v182.88,103.52
START  (via drill 0.61)
  Top 0.254: v163.83,113.68 v163.83,116.86 | v181.61,116.86 181.61,121.94 182.88,123.2 IC12.5
  Bottom 0.254: v163.83,113.68 156.84,113.68 IC18.3 | v163.83,116.86 v181.61,116.86
START\  (via drill 0.61)
  Top 0.254: v132.08,15.26 133.35,16.53 v133.35,47.01 132.72,47.64 132.72,49.55 133.35,50.18 133.35,62.24 132.72,62.88 132.72,66.06 v133.99,67.33 | v131.44,68.59 131.44,76.85 DMA8-11.11 | v184.15,100.98 184.15,121.94 185.42,123.2 IC12.6 | v167.64,95.27 v167.64,82.56 | v158.12,80.03 155.57,77.48 v155.57,67.96
  Bottom 0.254: IC12.6 187.32,122.57 188.59,122.57 189.23,123.2 189.23,127.65 188.59,127.65 186.69,129.55 160.02,129.55 IC10.10 | v132.08,15.26 DMA0-3.11 | v133.35,47.01 DMA4-7.11 | v131.44,68.59 132.72,67.33 v133.99,67.33 140.34,67.33 141.6,68.59 154.94,68.59 v155.57,67.96 | v184.15,100.98 183.51,100.34 176.53,100.34 173.99,97.81 173.99,94.63 168.28,94.63 v167.64,95.27 | v167.64,82.56 167.64,81.93 168.28,81.3 168.28,80.03 v158.12,80.03
VCC  (via drill 0.61)
  Top 0.508: IC23.14 93.98,19.07 96.52,21.61 IC36.6 96.52,24.14 93.98,26.69 v93.98,27.32 | v45.72,14.62 R2.2 | IC29.16 83.82,67.33 84.45,67.96 84.45,71.77 85.09,72.41 85.09,78.75 83.82,80.03 IC25.16 83.82,91.45 80.01,95.27 80.01,120.67 79.38,121.3 77.47,121.3 77.47,118.12 76.83,117.49 74.3,117.49 | IC35.20 60.33,41.29 60.33,41.92 59.69,42.56 C35.1 59.69,43.83 61.59,45.73 v61.59,47.01 | IC36.16 83.82,39.38 85.09,40.66 85.09,44.47 83.82,45.73 IC32.16 | C29.1 81.28,64.15 81.92,63.52 81.92,60.98 82.55,60.34 82.55,55.26 81.28,53.99 C32.1 | C33.1 91.44,103.52 90.17,104.79 90.17,116.22 91.44,117.49 C16.1 | 74.3,117.49 74.3,113.68 73.66,113.05 IC15.3 | 74.3,117.49 74.93,118.12 74.93,120.67 73.66,121.94 66.04,121.94 C15.1 66.04,117.49 64.77,116.22 64.77,104.79 66.04,103.52 C22.1 | v57.78,116.22 57.78,139.71 60.96,142.89 C3.1 | C34.1 24.13,42.56 24.77,41.92 24.77,41.29 IC34.20 | C26.1 24.13,75.58 24.77,74.95 24.77,74.31 IC26.20 27.94,71.14 27.94,44.47 v28.57,43.83 | C28.1 59.69,75.58 60.33,74.95 60.33,74.31 IC28.20 | C14.1 38.73,118.12 40.01,119.39 IC14.14 37.47,122.57 34.92,122.57 | 34.92,122.57 31.75,122.57 31.75,141.62 33.02,142.89 C2.1 | 6.35,113.68 10.16,117.49 C13.1 | 6.35,113.68 5.71,113.05 5.71,104.16 5.08,103.52 C20.1 | 6.35,113.68 6.35,141.62 5.08,142.89 C1.1 | IC2.16 35.56,146.06 33.02,148.6 33.02,149.24 32.38,149.88 10.79,149.88 10.79,149.24 7.62,146.06 IC1.16 | v38.73,77.48 39.37,78.12 39.37,91.45 34.92,95.9 34.92,122.57 | IC55.14 144.15,23.51 144.15,24.14 143.51,24.78 C40.1 v143.51,29.23 | DMA0-3.16 130.81,26.69 v130.81,29.23 132.08,30.5 v132.08,62.24
  Top 0.508: IC38.20 159.38,31.13 159.38,31.77 158.75,32.4 C38.1 158.12,33.04 158.12,26.69 161.93,26.69 163.83,24.78 163.83,18.43 v164.47,17.8 | C8.1 128.27,92.72 DMA8-11.16 126.36,88.28 126.36,62.88 v125.73,62.24 | DAR8-11.16 143.51,92.72 C27.1 | J7.2 177.8,41.29 175.9,43.2 175.9,45.73 177.8,47.64 J5.2 J4.2 J3.2 177.8,53.99 176.53,55.26 v176.53,63.52 | C31.1 158.75,66.69 159.38,66.06 159.38,65.42 IC31.20 | C39.1 128.27,61.61 128.91,60.98 128.91,60.34 DMA4-7.16 | C42.1 143.51,61.61 144.15,60.98 144.15,60.34 DAR4-7.16 | IC18.14 146.05,123.2 146.05,128.92 144.78,130.19 C10.1 | C6.1 144.78,142.89 143.51,141.62 143.51,137.17 147.32,133.36 IC10.14 | C17.1 119.38,118.76 118.11,120.03 118.11,128.92 116.84,130.19 C9.1 | C4.1 89.53,143.52 90.81,144.79 IC4.16 93.98,147.33 116.84,147.33 C5.1 116.84,142.89 118.11,141.62 118.11,134.63 119.38,133.36 IC9.14 | C37.1 204.47,32.4 205.1,31.77 205.1,31.13 IC37.20 | v200.66,35.58 201.29,36.21 201.29,56.53 IC30.20 205.1,61.61 205.1,62.24 204.47,62.88 C30.1 204.47,64.15 203.84,64.78 203.84,91.45 C44.1 | IC8.8 207.65,130.19 207.65,129.55 C48.1 | IC7.16 172.72,120.67 173.99,121.94 173.99,129.55 172.72,130.82 IC12.14 | IC24.20 158.75,97.81 C24.1 | R1.2 171.45,96.53 | 171.45,96.53 IC19.14 C19.1 | RA.1 RL.1 195.58,121.94 IC8.4 | C44.1 204.47,90.82 205.1,90.19 205.1,89.55 FIELD.16 | 203.84,111.78 203.84,114.31 C12.1 | 203.84,108.6 203.84,111.78 | 203.84,108.6 IC11.12 | 203.84,111.78 IC11.14 | 203.84,101.61 203.84,108.6 | 203.84,101.61 203.84,92.72 204.47,92.09 C44.1 | IC11.10 203.84,101.61 | v168.28,64.78 168.28,80.03 171.45,83.2 171.45,96.53 | v83.82,130.82 83.82,129.55 IC16.16
  Bottom 0.508: IC23.14 93.34,14.62 92.71,14.62 92.08,13.99 C23.1 90.81,13.99 88.27,16.53 85.09,16.53 84.45,17.16 67.94,17.16 IC41.16 64.77,13.99 C41.1 61.59,13.99 60.33,15.26 46.35,15.26 v45.72,14.62 | C29.1 81.92,64.78 82.55,65.42 83.19,65.42 IC29.16 | C25.1 81.92,80.03 82.55,80.66 83.19,80.66 IC25.16 | C36.1 81.92,29.23 82.55,29.86 83.19,29.86 IC36.16 85.72,28.59 92.71,28.59 v93.98,27.32 | C32.1 81.92,49.55 82.55,50.18 83.19,50.18 IC32.16 78.11,50.81 78.11,48.91 76.2,47.01 v61.59,47.01 | IC16.16 92.71,118.12 C16.1 90.81,118.12 87.63,114.95 68.58,114.95 67.94,115.58 59.69,115.58 58.42,116.86 | C3.1 61.59,143.52 62.23,144.16 62.87,144.16 IC3.16 | C22.1 66.67,102.89 67.31,103.52 67.94,103.52 IC22.14 | 45.72,116.22 v57.78,116.22 58.42,116.86 | 58.42,116.86 59.69,118.12 C15.1 67.31,118.12 IC15.14 | 45.72,116.22 IC14.3 | SV1.25 SV1.26 28.57,40.66 | 28.57,40.66 IC34.20 | 48.9,73.67 50.16,74.95 57.78,74.95 59.05,76.22 C28.1 | 48.9,73.67 47.62,72.41 | 47.62,72.41 46.35,71.14 RS08.2 | 47.62,72.41 27.94,72.41 26.67,73.67 IC26.20 | v28.57,43.83 28.57,40.66 | C2.1 33.66,143.52 34.29,144.16 34.92,144.16 IC2.16 | C1.1 5.71,143.52 6.35,144.16 6.99,144.16 IC1.16 | IC21.16 40.01,103.52 39.37,103.52 38.73,102.89 C21.1 37.47,102.89 36.83,102.25 5.08,102.25 C20.1 | IC13.14 11.43,118.12 C13.1 10.16,117.49 21.59,117.49 22.86,116.22 45.72,116.22 | 48.9,73.67 46.99,75.58 46.99,77.48 v38.73,77.48 | INTENB.16 174.62,17.16 173.99,17.16 173.35,16.53 C43.1 172.09,16.53 170.81,17.8 v164.47,17.8 | C46.1 128.91,27.96 130.18,29.23 v130.81,29.23 v143.51,29.23 157.48,29.23 158.75,30.5 IC38.20 | C8.1 128.91,94 129.54,93.36 137.16,93.36 137.79,92.72 141.6,92.72 142.88,94 C27.1
  Bottom 0.508: DMA4-7.16 130.81,59.7 131.44,60.34 135.25,60.34 135.89,60.98 141.6,60.98 142.88,59.7 DAR4-7.16 | C42.1 148.59,62.24 149.86,63.52 157.48,63.52 158.75,64.78 IC31.20 v168.28,64.78 175.26,64.78 v176.53,63.52 | v125.73,62.24 C39.1 v132.08,62.24 | C6.1 145.41,143.52 146.05,144.16 146.69,144.16 IC6.16 | IC18.14 149.22,118.76 148.59,118.76 147.96,118.12 C18.1 146.69,118.12 146.05,117.49 119.38,117.49 C17.1 120.02,118.12 120.65,118.76 121.28,118.76 IC17.16 | C10.1 145.41,130.82 146.05,131.46 146.69,131.46 IC10.14 149.22,134 166.37,134 169.54,130.82 C7.1 170.81,130.82 171.45,131.46 172.09,131.46 IC12.14 | IC9.14 118.75,131.46 118.11,131.46 117.47,130.82 C9.1 116.84,130.19 84.45,130.19 v83.82,130.82 | C5.1 117.47,143.52 118.11,144.16 118.75,144.16 IC5.14 | v200.66,35.58 201.29,35.58 203.84,33.04 C37.1 | IC8.8 204.47,132.09 197.49,139.08 196.85,139.08 C45.+ | C11.1 170.81,118.12 171.45,118.76 172.09,118.76 IC7.16 174.62,121.3 191.13,121.3 193.04,119.39 RL.1 | IC24.20 R1.2 | IC11.10 204.47,101.61 201.93,104.16 IC11.4 196.85,104.16 194.94,102.25 176.53,102.25 173.35,99.08 C19.1 | RA.1 198.75,119.39 203.84,114.31 C12.1 | C48.1 208.28,125.75 200.66,125.75 199.39,124.47 IC8.4
WE\  (via drill 0.61)
  Top 0.254: v48.26,82.56 48.26,77.48 49.53,76.22 49.53,65.42 v48.9,64.78 | v78.74,81.93 IC22.5 | v115.57,139.71 114.94,139.08 114.94,102.25 116.2,100.98 116.2,100.34 111.76,95.9 v111.76,86.38
  Bottom 0.254: 77.47,81.93 52.7,81.93 50.8,83.83 49.53,83.83 v48.26,82.56 | 77.47,81.93 v78.74,81.93 | v48.9,64.78 47.62,63.52 RS08.8 | v115.57,139.71 117.47,139.71 118.11,139.08 127.64,139.08 128.27,139.71 148.59,139.71 149.22,139.08 155.57,139.08 IC6.5 | v111.76,86.38 108.58,83.2 106.05,83.2 102.23,79.39 82.55,79.39 81.92,78.75 80.64,78.75 77.47,81.93
WLS  (via drill 0.61)
  Top 0.254: v185.42,84.47 v185.42,24.14 | v154.31,85.11 154.94,85.74 154.94,99.71 v148.59,106.06 | v137.16,106.7 133.35,110.5 133.35,115.58 130.81,118.12 | 130.81,118.12 130.81,121.94 129.54,123.2 IC9.5 | v58.42,25.41 59.05,26.05 59.05,31.13 59.69,31.77 59.05,32.4 59.05,41.92 58.42,42.56 58.42,45.1 v60.33,47.01 | v74.93,49.55 74.93,114.95 v76.2,116.22 | v125.09,114.95 127.64,117.49 130.81,117.49 130.81,118.12
  Bottom 0.254: v185.42,24.14 195.58,24.14 196.85,22.88 IC37.4 | v185.42,84.47 184.78,85.11 v154.31,85.11 | v148.59,106.06 147.96,106.7 v137.16,106.7 | v58.42,25.41 55.88,25.41 54.61,26.69 42.55,26.69 41.27,27.96 SV1.15 | v60.33,47.01 61.59,48.27 69.22,48.27 70.48,49.55 v74.93,49.55 | v76.2,116.22 76.83,116.86 88.27,116.86 92.71,121.3 97.16,121.3 97.79,120.67 97.79,114.95 v125.09,114.95
WLS\
  Top 0.254: IC9.6 132.08,125.75 128.27,129.55 128.27,133.36 125.73,135.9 125.73,139.08 121.92,142.89 IC5.13
WRITING  (via drill 0.61)
  Top 0.254: IC10.5 151.13,130.82 151.13,133.36 149.86,134.63 IC6.2 | IC41.14 71.75,14.62 73.03,14.62 IC41.13 73.66,16.53 75.56,18.43 v75.56,20.97 | v41.27,19.7 41.27,7 v42.55,5.73 55.24,5.73 v55.24,21.61 55.24,31.13 54.61,31.77 50.8,31.77 50.8,43.83 49.53,45.1 v49.53,49.55 | v120.65,135.27 v120.65,130.19 | v17.78,129.55 13.97,125.75 13.97,88.92 14.61,88.28 14.61,60.34 13.97,59.7 13.97,50.18 14.61,49.55 14.61,25.41 13.97,24.78 13.97,14.62 v21.59,7
  Bottom 0.254: v41.27,19.7 36.83,19.7 36.2,20.34 SV1.9 | v49.53,49.55 48.26,50.81 RS08.18 | v75.56,20.97 69.22,20.97 68.58,21.61 v55.24,21.61 | v120.65,135.27 135.25,135.27 137.16,137.17 146.05,137.17 146.05,138.44 146.69,139.08 147.96,139.08 IC6.2 | v120.65,130.19 120.02,129.55 v17.78,129.55 | v21.59,7 36.83,7 38.1,5.73 v42.55,5.73

## Text on the board
Bottom: RS08 | VRS | RF08 Debug | VRS | RS08 | VRS | RF08 | VRS
tPlace: RF08 | VRS
tValues: RF08 Debug | VRS | RS08 | VRS | RS08 | VRS